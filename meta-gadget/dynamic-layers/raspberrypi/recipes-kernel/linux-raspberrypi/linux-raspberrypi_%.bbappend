FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:ab-mutable = " file://rpi-ab-mutable-gadget.cfg"
