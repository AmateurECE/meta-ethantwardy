inherit bundle

RAUC_BUNDLE_SLOTS = "rootfs"
RAUC_SLOT_rootfs = "${ROOTFS_IMAGE_TARGET}"

RAUC_BUNDLE_FORMAT = "verity"
