FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://backup-server.cfg"
