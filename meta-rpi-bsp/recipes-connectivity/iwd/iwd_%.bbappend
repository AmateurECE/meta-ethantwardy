FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
INITSCRIPT_PACKAGES = "${PN}"
INITSCRIPT_NAME = "iwd"
