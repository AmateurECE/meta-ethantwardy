require email-gadget.inc

IMAGE_FSTYPES = "wic"
WKS_FILE = "sdimage-raspberrypi.wks"
