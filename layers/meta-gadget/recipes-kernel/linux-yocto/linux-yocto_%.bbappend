FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://overlay.cfg \
    file://9pfs.cfg \
"
