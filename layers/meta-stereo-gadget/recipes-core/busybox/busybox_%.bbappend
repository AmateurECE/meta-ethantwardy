FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://stereo.cfg"
