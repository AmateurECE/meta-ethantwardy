SUMMARY = "A small image just capable of allowing a kernel to boot."

IMAGE_INSTALL = "packagegroup-core-boot"

LICENSE = "MIT"

inherit image
