DEPENDS:remove = "lua"
DEPENDS:append = " lua53"